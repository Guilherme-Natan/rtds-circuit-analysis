V1 1 0 V
L1 1 2 L
R1 2 0 R
C1 2 0 C
