V1 1 0 V
L1 1 1_2A L1
L2 1_2A 1_2B L2
L3 1_2C 1_2B L3
L4 2 1_2C L4
R1 2 0 R
C1 2 0 C1
C2 0 2 C2
C3 2 0 C3
C4 0 2 C4
