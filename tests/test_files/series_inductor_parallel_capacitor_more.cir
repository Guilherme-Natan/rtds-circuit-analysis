V1 1 0 V
L1 1 1_2a L1
L2 1_2a 1_2b L2
L3 1_2b 1_2c L3
L4 1_2c 2 L4
R1 2 0 R
C1 2 0 C1
C2 2 0 C2
C3 2 0 C3
C4 2 0 C4
