V1 2 1 10
R1 3 2 10k
R2 0 3 5K
V2 0 1 5
V3 3 0 3
V4 3 4 7
R3 4 0 8K
