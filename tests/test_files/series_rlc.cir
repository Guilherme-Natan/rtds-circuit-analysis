V1 1 0 V
R1 1 2 R
L1 2 3 L
C1 3 0 C
