Vin 1 0 Vin
R1 1 1_2A R1
L1A 1_2A 1_2B L1A
L1B 1_2B 2 L1B
L2A 2 2_3A L2A
R2 2_3A 2_3B R2
L2B 2_3B 3 L2B
L3A 1 1_3A L3A
L3B 1_3A 1_3B L3B
R3 1_3B 3 R3
C1A 2 0 C1A
C1B 2 0 C1B
C2A 3 0 C2A
C2B 3 0 C2B
