Vin 1 0 Vin
R1 1 1_2 R1
L1 1_2 2 L1
R2 2 2_3 R2
L2 2_3 3 L2
R3 1 1_3 R3
L3 1_3 3 L3
C1 2 0 C1
C2 3 0 C2
