R1 1 0 R1
V1 2 1 V1
R2 3 2 R2
V2 4 3 V2
R3 5 4 R3
