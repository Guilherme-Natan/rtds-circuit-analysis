I1 1 0 I
R1 1 0 R
L1 1 0 L
C1 1 0 C
