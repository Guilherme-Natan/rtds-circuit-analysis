V1 1 0 V
L1 1_2A 1 L1
L2 1_2B 1_2A L2
L3 1_2B 1_2C L3
L4 1_2C 2 L4
R1 2 0 R
C1 0 2 C1
C2 2 0 C2
C3 0 2 C3
C4 2 0 C4
