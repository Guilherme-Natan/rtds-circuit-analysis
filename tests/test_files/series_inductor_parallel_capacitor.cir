V1 1 0 V
L1 1 1_2 L1
L2 1_2 2 L2
R1 2 0 R
C1 2 0 C1
C2 2 0 C2
